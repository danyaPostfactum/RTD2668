# Keil uVision project sparrow.uvproj, settings and files
target 2668_4M (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: sparrow +hex
  BeforeMake: C:\Keil\ARM\BIN40\fromelf.exe --bin -o ./output/2668_4M.bin ./output/2668_4M.axf
  AfterMake: Merge256K_4M.bat
  c flags: Optimize=9
  c define: RTD2668="1" ,SPARROW="1",TTX_IS_SUPPORTED\="1",DV_SIM="0" ,TTX_RELEASE="1"
  c include: ..\include\;..\include\sparrow\;..\ap\ui\realtek\include\;..\ap\pcb\longyuan\include\;..\include\ttx\;..\drivers\ttx\inc\;..\drivers\ttx\src\;..\DRIVERS\TTX\PORTS\SPARROW\real\;..\DRIVERS\TTX\PORTS\SPARROW\ttx\buff\inc\;..\DRIVERS\TTX\PORTS\SPARROW\ttx\disp\inc\;..\DRIVERS\TTX\PORTS\SPARROW\ttx\misc\inc\;..\DRIVERS\TTX\PORTS\SPARROW\ttx\src\inc\;..\drivers\ttx\ports\sparrow\
  group library
    ../lib/: L51_BANK.A51 STARTUP.A51
  group system
    ../system/: lib_info.c timer_event_sys_table.c isr_table.c main.c modestate.c rt_storage.c timer_event.c message.c system.c
    ../ap/ui/realtek/para/: sys_info.c
  group flow
    ../flow/: userinput.c auto.c display.c flow_audio.c flow_color.c flow_display.c flow_scaler.c framesync.c mode.c power.c source.c flow_struct.c
    ../ap/ui/realtek/para/: flow_parameter.c panel_parameter.c
    ../ap/pcb/longyuan/: pcb_padctrl.c
  group ui
    ../ap/ui/realtek/: ui_struct.c cni_table.c mode_customer.c modeinfo_parameter.c osdcontrol.c osdcore.c osdcorefactory.c osdflow.c osdfont.c osdfunction.c osdparameter.c osdstring.c storage_system.c timer_event_ui_table.c tv.c ui_ctrl.c ui_default.c
    ../ap/ui/realtek/vip/: VIP_quality_parameter.c
    ../flow/: osdvbi.c
  group pcb_customer
    ../ap/pcb/longyuan/: pcb_source.c pcb_ctrl.c
  group audio
    ../drivers/audio/: audio_tv.c audio_host.c audio_hwp_lv.c audio_if.c audio_table_default.c
    ../ap/ui/realtek/: audio_table.c
  group char
    ../drivers/char/: uart_access.c lsadc.c monitor.c rosprintf.c rosprintf_para.c
  group flash
    ../drivers/flash/: spi_flash_common.c spi_flash.c
  group hdmi
    ../drivers/hdmi/: hdmiSparrow.c hdmiHdmi.c hdmiPhy.c
  group i2c
    ../drivers/i2c/: i2c.c
  group ifd
    ../drivers/ifd/: ifd.c ifd_sparrow.c ifd_factorymode.c
  group irrc
    ../drivers/irrc/: irrc.c
  group panel
    ../drivers/panel/: panelapi.c panel_library.c
  group pcb
    ../drivers/pcb/: pcb_utility.c
  group pwm
    ../drivers/pwm/: pwm.c
  group scaler
    ../drivers/scaler/: scaler_pll.c adjust.c scaler.c
  group scaler_ddomain
    ../drivers/scaler_ddomain/: scaler_display.c
  group scaler_idomain
    ../drivers/scaler_idomain/: vgip.c abl.c adc.c auto_soy.c measure.c smartfit.c syncproc.c
  group signal
    ../drivers/signal/: sig_avsv.c sig_hdmi.c sig_scart.c sig_tv.c sig_vga.c sig_ypbpr.c
  group sparrow
    ../drivers/sparrow/: spi_dma.c boot.c imem.c isr_utility.c rtdctrl.c rtdctrl1.a51 DSA51.LIB DSC51.LIB DSlib.LIB
  group timer
    ../drivers/timer/: timer.c
  group tuner
    ../drivers/tuner/: silicon_tuner.c silicon_tuner_old.c tuner_table.c tuner.c
  group vbi
    ../drivers/vbi/: drv_vbi_ppr.c drv_vbi_cc_verify.c drv_vbi_slr.c
    ../flow/: closecaption.c
  group video
    ../drivers/video/: video.c
  group vip
    ../drivers/vip/: ypbpr_auto.c color.c color_parameter.c digital_filter.c peaking.c ultrazoom.c ultrazoom_parameter.c
target 2668_8M (MCS-51)
  device: DW-8051 Synopsys
  cpu: IRAM(0-0xFF) CLOCK(33000000) MODDP2
  output: sparrow +hex
  AfterMake: Merge256K.bat
  c flags: Optimize=9
  c define: as above
  c include: ..\include\;..\include\sparrow\;..\ap\ui\realtek\include\;..\ap\pcb\longyuan\include;..\include\ttx\;..\drivers\ttx\inc\;..\drivers\ttx\src\;..\DRIVERS\TTX\PORTS\SPARROW\real\;..\DRIVERS\TTX\PORTS\SPARROW\ttx\buff\inc\;..\DRIVERS\TTX\PORTS\SPARROW\ttx\disp\inc\;..\DRIVERS\TTX\PORTS\SPARROW\ttx\misc\inc\;..\DRIVERS\TTX\PORTS\SPARROW\ttx\src\inc\;..\drivers\ttx\ports\sparrow\
